# Keil uVision project liteUSB.uvprojx, settings and files
target STM32F10C-FS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: liteUSB +hex
  AfterMake: fromelf.exe --bin -o./liteUSB.bin ./obj/liteUSB.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL,USE_STM3210C_EVAL,USE_USB_OTG_FS,USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\libs\CMSIS\Device\ST\STM32F10x\Include;..\..\libs\STM32F10x_StdPeriph_Driver\inc;..\..\libs\STM32_USB_OTG_Driver\inc;..\..\libs\STM32_USB_HOST_Library\Core\inc;..\..\libs\STM32_USB_HOST_Library\Class\MSC\inc;..\..\BSP\STM32_EVAL;..\..\BSP\STM32_EVAL\Common;..\..\BSP\STM32_EVAL\STM3210C_EVAL;..\..\fatFS\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../src/: main.c xprintf.c usb_bsp.c usbh_usr.c stm32fxxx_it.c startup_stm32f10x_cl.s
  group usb
    ../../libs/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../libs/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
    ../../libs/STM32_USB_OTG_Driver/src/: usb_hcd.c usb_core.c usb_hcd_int.c
  group fatFS
    ../../fatFS/src/: ff.c fattime.c
  group STM32F10x
    ../src/: system_stm32f10x.c
  group STM32_EVAL
    ../../BSP/STM32_EVAL/Common/: lcd_log.c
  group STM3210C_EVAL
    ../../BSP/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval.c stm3210c_eval_ioe.c stm3210c_eval_lcd.c stm3210c_eval_spi_sd.c
  group StdPeriph_Driver
    ../../libs/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c
target STM32F2xG-FS (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  output: STM322xG-EVAL_FS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_FS
  c include: ..\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\..\Utilities\Third_Party\fat_fs\inc
  library: MicroLIB
target STM32F4xG-FS (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM324xG-EVAL_FS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_STM324xG_EVAL,USE_USB_OTG_FS
  c include: ..\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\..\..\Utilities\Third_Party\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F2xG-HS (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM322xG-EVAL_HS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_HS,USE_ULPI_PHY
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target STM32F4xG-HS (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  output: STM324xG-EVAL_HS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_STM324xG_EVAL,USE_USB_OTG_HS,USE_ULPI_PHY
  c include: as above
  library: MicroLIB
software components: CMSIS:CORE 5.0.1
